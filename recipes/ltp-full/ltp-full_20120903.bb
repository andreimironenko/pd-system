require ltp-full.inc