require ${OEBASE}/arago/recipes/ti/ti-codec-engine.inc
require ti-codec-engine.inc


