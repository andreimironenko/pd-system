require ti-slog.inc