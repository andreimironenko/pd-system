require ti-cgt6x.inc

PE = "1"
PVwithdots = "7.3.1"



