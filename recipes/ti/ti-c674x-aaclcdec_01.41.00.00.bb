DESCRIPTION = "TI AAC LC Decoder for C674x devices"
SECTION = "multimedia"
LICENSE = "TI Proprietary"

require ti-c6accel.inc

PVExtra="_elf"


