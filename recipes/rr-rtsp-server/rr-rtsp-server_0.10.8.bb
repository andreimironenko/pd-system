require rr-rtsp-server.inc

SRCREV = "${PN}_${PV}"
