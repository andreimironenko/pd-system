require system-security.inc

PV ="${PN}_1.0.2"
SRCREV = "${PV}"
