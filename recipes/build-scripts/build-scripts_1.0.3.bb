require build-scripts.inc

PV ="${PN}_1.0.3"
SRCREV = "${PV}"
