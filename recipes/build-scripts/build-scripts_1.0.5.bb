require build-scripts.inc

PV ="${PN}_1.0.5"
SRCREV = "${PV}"
