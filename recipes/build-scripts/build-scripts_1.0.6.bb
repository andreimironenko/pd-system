require build-scripts.inc

SRCREV = "${PV}"
