require build-scripts.inc

PV ="${PN}_1.0.4"
SRCREV = "${PV}"
