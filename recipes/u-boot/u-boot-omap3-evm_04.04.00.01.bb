require u-boot-omap3-evm.inc

S = "${WORKDIR}/git"





