require gstreamer-ti.inc

COMPATIBLE_MACHINE = "(dm365-htc|dm365-evm)"

PV = "svnr919"

SRCREV = "${PV}"
BRANCH ?=master

