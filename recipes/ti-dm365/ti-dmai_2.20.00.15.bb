require ti-dmai.inc

PV = "2_20_00_15"
PR = "r1"
 
COMPATIBLE_MACHINE = "(dm365-htc|dm365-evm)"

#SRCREV = "${PV}"
SRCREV = "b1e674eaafb6f3b61b38bb2f1cc48af112f34745"
BRANCH ?= "master"



