require ti-codec-engine.inc

COMPATIBLE_MACHINE = "(dm365-htc|dm365-evm)"

PV = "2_26_02_11"

SRCREV = "${PV}"
BRANCH ?= "master"
