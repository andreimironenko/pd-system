require ti-codecs-dm365.inc

COMPATIBLE_MACHINE = "(dm365-htc|dm365-evm)"

PV="4_02_00_00"

SRCREV = "${PV}"
BRANCH ?= "master"
