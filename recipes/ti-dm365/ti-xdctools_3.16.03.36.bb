require ti-xdctools.inc

COMPATIBLE_MACHINE = "(dm365-evm)"

PV = "3_16_03_36"

#SRCREV = "${PV}"
SRCREV = "1b67761d36895239914eb533e53fe721703b961b"

BRANCH ?=master

