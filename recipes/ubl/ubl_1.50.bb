require ubl.inc


SRCREV = "${PV}"
BRANCH = "master"

S = "${WORKDIR}/git"