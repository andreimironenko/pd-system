require linux-omap3-evm.inc

KVER = "2.6.37"
PSPREL = "04.04.00.01"

SCRIPTS_DIR = "${WORKDIR}"

