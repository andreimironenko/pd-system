require omap3-sgx-modules.inc

EXTRA_SRC_URI = ""
#EXTRA_SRC_URI = "file://${OEBASE}/arago/recipes/powervr-drivers/${PN}/0001-GFX_Linux_KM-Fix-os-functions.patch;striplevel=2 \
#"

